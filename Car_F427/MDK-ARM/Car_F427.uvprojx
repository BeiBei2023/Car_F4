# Keil uVision project Car_F427.uvprojx, settings and files
target Car_F427 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Car_F427 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../BSP;../BSP/SBUS;../BSP/M3508;../BSP/PID;../BSP/TASKS;../BSP/WHEEL;../BSP/ST7735S;../BSP/AHT20;../BSP/ADC;../BSP/BUTTON;../BSP/Modbus;../BSP/easylogger;../BSP/easylogger/inc;../BSP/easylogger/port;../BSP/IMU;../BSP/LVGL;../BSP/LVGL/src;../BSP/LVGL/demos;../BSP/LVGL/demos/widgets;../BSP/LVGL/ui;../BSP/LVGL/ui/custom;../BSP/LVGL/ui/generated;../BSP/LVGL/ui/generated/guider_customer_fonts;../BSP/LVGL/ui/generated/guider_fonts;../BSP/LVGL/ui/generated/images
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP/SBUS
    ../BSP/SBUS/: sbus.c
  group BSP/M3508
    ../BSP/M3508/: drv_can.c motor.c
  group BSP/PID
    ../BSP/PID/: pid.c
  group BSP/TASK
    ../BSP/TASKS/: callback.c motor_control.c send_motor_data.c sever_init.c
  group BSP/WHEEL
    ../BSP/WHEEL/: wheel.c
  group BSP/ST7735S
    ../BSP/ST7735S/: st7735s.c
  group BSP/AHT20
    ../BSP/AHT20/: aht20.c
  group BSP/ADC
    ../BSP/ADC/: adc_v.c
  group BSP/BUTTON
    ../BSP/BUTTON/: multi_button.c button_config.c
  group BSP/MODBUS
    ../BSP/Modbus/: Modbus.c UARTCallback.c
  group BSP/EASYLOGGER
    ../BSP/easylogger/src/: elog.c elog_utils.c
    ../BSP/easylogger/port/: elog_port.c
  group BSP/IMU
    ../BSP/IMU/: QMI8658A.c
  group LVGL/APP
    ../BSP/LVGL/ui/custom/: custom.c
    ../BSP/LVGL/ui/generated/images/: _555_alpha_160x80.c
    ../BSP/LVGL/ui/generated/: events_init.c gui_guider.c setup_scr_main.c setup_scr_Voltage.c widgets_init.c setup_scr_Temperature.c setup_scr_Humidity.c setup_scr_IO_State.c
    ../BSP/LVGL/ui/generated/guider_fonts/: lv_font_yousheTittle_30.c lv_font_yousheTittle_35.c lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_SourceHanSerifSC_Regular_11.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_yousheTittle_16.c
  group LVGL/CORE
    ../BSP/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/DRAW
    ../BSP/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../BSP/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../BSP/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../BSP/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../BSP/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../BSP/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../BSP/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../BSP/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../BSP/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group LVGL/EXTRA
    ../BSP/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../BSP/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../BSP/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../BSP/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../BSP/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../BSP/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../BSP/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../BSP/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../BSP/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../BSP/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../BSP/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../BSP/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../BSP/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../BSP/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../BSP/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../BSP/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../BSP/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../BSP/LVGL/src/extra/others/msg/: lv_msg.c
    ../BSP/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../BSP/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../BSP/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../BSP/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../BSP/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../BSP/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../BSP/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../BSP/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../BSP/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../BSP/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../BSP/LVGL/src/extra/widgets/led/: lv_led.c
    ../BSP/LVGL/src/extra/widgets/list/: lv_list.c
    ../BSP/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../BSP/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../BSP/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../BSP/LVGL/src/extra/widgets/span/: lv_span.c
    ../BSP/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../BSP/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../BSP/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../BSP/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../BSP/LVGL/src/extra/widgets/win/: lv_win.c
    ../BSP/LVGL/src/extra/: lv_extra.c
  group LVGL/FONT
    ../BSP/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/HAL
    ../BSP/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/MISC
    ../BSP/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/WIDGETS
    ../BSP/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/PORTING
    ../BSP/LVGL/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL/CONFIG
    ../BSP/LVGL/: lv_conf.h lvgl.h
  group LVGL/DEMO/STRESS
    ../BSP/LVGL/demos/stress/: lv_demo_stress.c
  group LVGL/DEMO/WIDGETS
    ../BSP/LVGL/demos/widgets/: lv_demo_widgets.c
    ../BSP/LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group LVGL/DEMO/KEYPAD_ENCODER
    ../BSP/LVGL/demos/keypad_encoder/: lv_demo_keypad_encoder.c
software components: CMSIS:CORE 4.3.0
